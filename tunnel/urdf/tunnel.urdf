Commit message: Update tunnel.urdf
reduce the mass value of the tunnel

File: tunnel/urdf/tunnel.urdf (robot description, URDF)
Before this commit: robot tunnel, 1 links, 0 joints
Links:
- link base_link: mass 27830000 -> 27

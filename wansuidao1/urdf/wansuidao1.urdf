Commit message: Update wansuidao1.urdf
Reduce the huge value of mass of the tunnel model to prevent the movement of model.

File: wansuidao1/urdf/wansuidao1.urdf (robot description, URDF)
Before this commit: robot wansuidao1, 1 links, 0 joints
Links:
- link suidaos: mass 40275000 -> 40

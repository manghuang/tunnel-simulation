Commit message: Update suidao2.urdf
reduce the mass value of tunnel model

File: suidao2/urdf/suidao2.urdf (robot description, URDF)
Before this commit: robot suidao2, 1 links, 0 joints
Links:
- link base_link: mass 27826000 -> 27
